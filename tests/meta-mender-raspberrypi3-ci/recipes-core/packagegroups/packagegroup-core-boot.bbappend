RDEPENDS:${PN}:append = " \
    mender-qa \
    "