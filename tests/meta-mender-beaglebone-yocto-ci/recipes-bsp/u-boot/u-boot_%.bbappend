FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"

SRC_URI:append = " file://reenable_uenvcmd.patch"
