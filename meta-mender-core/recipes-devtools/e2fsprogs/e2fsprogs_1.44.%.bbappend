FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI:append = " file://0001-Do-not-use-metadata_csum-feature-on-ext4-by-default.patch"
