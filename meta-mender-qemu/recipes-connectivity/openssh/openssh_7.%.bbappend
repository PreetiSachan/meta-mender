DEPENDS:remove = "openssl"
DEPENDS:append = " openssl10"
